# IAR project lm4f.ewp, settings and files
configuration IAR_DEBUG (ARM, debug)
  General.OGChipSelectEditMenu: LM4F120H5QR TexasInstruments LM4F120H5QR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: F_CPU=80000000L; ARDUINO=101; ENERGIA=13; ewarm; USE_FREERTOS
  ICCARM.CCIncludePath2: cores/lm4f; cores/lm4f/driverlib; cores/lm4f/freertos; cores/lm4f/freertos/IAR; cores/lm4f/inc; libraries/AIR430BoostEuropeETSI; libraries/AIR430BoostUSAFCC; libraries/EduBPMKII_Screen; libraries/EEPROM; libraries/Ethernet; libraries/FreeRTOS; libraries/Servo; libraries/SPI; libraries/Stepper; libraries/Temboo; libraries/TMP006; libraries/WiFi; libraries/Wire; variants/stellarpad
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: lm4f.srec
  ILINK.IlinkOutputFile: cpp.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: lm4f.cpp startup_ewarm.c
  group cores/lm4f
    cores/lm4f/: Arduino.h binary.h Client.h Energia.h HardwareSerial.cpp HardwareSerial.h IPAddress.cpp IPAddress.h itoa.c itoa.h main.cpp new.cpp new.h Print.cpp Print.h Printable.h random.c Server.h startup_gcc.c Stream.cpp Stream.h Tone.cpp Udp.h WCharacter.h WInterrupts.c wiring.c wiring_analog.c wiring_digital.c wiring_private.h wiring_pulse.c wiring_shift.c WMath.cpp WString.cpp WString.h
  group cores/lm4f/driverlib
    cores/lm4f/driverlib/: adc.c adc.h aes.c aes.h can.c can.h comp.c comp.h cpu.c cpu.h crc.c crc.h debug.h des.c des.h eeprom.c eeprom.h emac.c emac.h epi.c epi.h epi_workaround_ccs.s flash.c flash.h fpu.c fpu.h gpio.c gpio.h hibernate.c hibernate.h i2c.c i2c.h interrupt.c interrupt.h lcd.c lcd.h mpu.c mpu.h pin_map.h pwm.c pwm.h qei.c qei.h rom.h rom_map.h rtos_bindings.h shamd5.c shamd5.h ssi.c ssi.h sw_crc.c sw_crc.h sysctl.c sysctl.h sysexc.c sysexc.h systick.c systick.h timer.c timer.h uart.c uart.h udma.c udma.h usb.c usb.h watchdog.c watchdog.h
  group cores/lm4f/freertos
    cores/lm4f/freertos/: croutine.c croutine.h energia_freertos_hooks.c FreeRTOS.h FreeRTOSConfig.h heap_4.c list.c list.h mpu_wrappers.h osi.h osi_freertos.c portable.h projdefs.h queue.c queue.h semphr.h StackMacros.h task.h tasks.c timers.c timers.h
  group cores/lm4f/freertos/IAR
    cores/lm4f/freertos/IAR/: port.c portasm.s portmacro.h
  group cores/lm4f/inc
    cores/lm4f/inc/: asmdefs.h hw_adc.h hw_aes.h hw_can.h hw_ccm.h hw_comp.h hw_des.h hw_eeprom.h hw_emac.h hw_epi.h hw_fan.h hw_flash.h hw_gpio.h hw_hibernate.h hw_i2c.h hw_ints.h hw_lcd.h hw_memmap.h hw_nvic.h hw_pwm.h hw_qei.h hw_shamd5.h hw_ssi.h hw_sysctl.h hw_sysexc.h hw_timer.h hw_types.h hw_uart.h hw_udma.h hw_usb.h hw_watchdog.h lm4f120h5qr.h tm4c123gh6pm.h tm4c1294ncpdt.h tm4c129xnczad.h
  group libraries/SPI
    libraries/SPI/: SPI.cpp SPI.h
  group variants/stellarpad
    variants/stellarpad/: part.h pins_energia.h
