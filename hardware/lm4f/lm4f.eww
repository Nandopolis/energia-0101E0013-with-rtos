<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\lm4f.ewp</path>
  </project>
  <batchBuild/>
</workspace>


